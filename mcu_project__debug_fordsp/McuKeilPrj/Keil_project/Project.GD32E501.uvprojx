# Keil uVision project Project.GD32E501.uvprojx, settings and files
target GD32E501 (6190000::V6.19::ARMCLANG)
  device: GD32E501RE GigaDevice
  pack: GigaDevice.GD32E501_DFP.1.0.2
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Project.axf
  c flags: OneElfS=1 v6Lang=3 wLevel=3
  c define: __MICROLIB GD32E501
  c misc: -xc -Wno-packed -Wno-missing-variable-declarations -Wno-missing-prototypes -Wno-missing-noreturn -Wno-nonportable-include-path -Wno-reserved-id-macro -Wno-unused-macros -Wno-documentation-unknown-command -Wno-documentation -Wno-license-management -Wno-parentheses-equality -Wno-reserved-identifier
  c include: ../../mcu;../../mcu/GDE501_fireware;../../mcu/GDE501_fireware/Firmware/CMSIS;../../mcu/GDE501_fireware/Firmware/CMSIS/GD/GD32E501/Include;../../mcu/GDE501_fireware/Firmware/GD32E501_standard_peripheral/Include;../../mcu/GDE501_fireware/Utilities;../../tec_control;../../driver;../../other;../../rssi;..\..\update
  asm define: GD32E501
  asm misc: --diag_suppress=A1950W
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ./Project.GD32E501.sct
  link misc: --summary_stderr --info summarysizes --load_addr_map_info --entry=Reset_Handler
  group mcu_Application
    ../../mcu/GDE501_fireware/: systick.c gd32e501_it.c i2c_opt_ie.c
    ../../mcu/: com_usart_comm.c i2c_comm.c mcu_config_public.c mcu_system_comm.c dac_comm.c adc_comm.c sff_8472.c timer_comm.c
  group mcu_CMSIS
    ../../mcu/GDE501_fireware/Firmware/CMSIS/GD/GD32E501/Source/: system_gd32e501.c
  group mcu_Peripherals
    ../../mcu/GDE501_fireware/Firmware/GD32E501_standard_peripheral/Source/: gd32e501_adc.c gd32e501_cla.c gd32e501_cmp.c gd32e501_crc.c gd32e501_dac.c gd32e501_dbg.c gd32e501_dma.c gd32e501_exti.c gd32e501_fmc.c gd32e501_fwdgt.c gd32e501_gpio.c gd32e501_i2c.c gd32e501_mdio.c gd32e501_misc.c gd32e501_pmu.c gd32e501_rcu.c gd32e501_rtc.c gd32e501_spi.c gd32e501_syscfg.c gd32e501_timer.c gd32e501_usart.c gd32e501_wwdgt.c
  group mcu_Startup
    ../../mcu/GDE501_fireware/Firmware/CMSIS/GD/GD32E501/Source/ARM/: startup_gd32e501.s
  group mcu_Utilities
    ../../mcu/GDE501_fireware/Utilities/: gd32e501_eval.c
  group Doc
    ../: readme.txt
  group driver
    ../../driver/GN7153/: gn7153.c
    ../../driver/GN7161/: gn7161.c
    ../../driver/UX3326/: ux3326.c
  group other
    ../../other/: sgm41295.c sgm2508.c
  group rssi
    ../../rssi/: sgm41282c.c
  group tec_control
    ../../tec_control/: tec_comm.c pid.c
  group source
    ../: main.c
  group update
    ../../update/: update_comm.c
software components: CMSIS:CORE 5.6.0
