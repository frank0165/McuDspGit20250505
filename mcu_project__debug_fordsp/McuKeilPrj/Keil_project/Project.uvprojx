# Keil uVision project Project.uvprojx, settings and files
target GD32E501 (6190000::V6.19::ARMCLANG)
  device: GD32E501RE GigaDevice
  pack: GigaDevice.GD32E501_DFP.1.0.2
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Project_app
  AfterMake: D:\D\app\kevil5\ARM\ARMCLANG\bin\fromelf.exe --bin --output .\Output\Project_app.bin .\Output\Project_app.axf
  AfterMake: renamecompile.bat
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E501,EXT_CTRL_MCU,CHIP_TYPE=1
  c include: ..\..\src\mcu;..\..\src\mcu\GDE501_fireware;..\..\src\mcu\GDE501_fireware\Firmware\CMSIS;..\..\src\mcu\GDE501_fireware\Firmware\CMSIS\GD\GD32E501\Include;..\..\src\mcu\GDE501_fireware\Firmware\GD32E501_standard_peripheral\Include;..\..\src\mcu\GDE501_fireware\Utilities;..\..\src\mcu\i2c_opt_ie;..\..\src\mcu\adc_sample_comm;..\..\src\mcu\dac_comm;..\..\src\mcu\i2c_comm;..\..\src\include;..\..\src\driver\dsp_fsl;..\..\src\driver\GN7153;..\..\src\driver\GN7161;..\..\src\driver\UX3326;..\..\src\other;..\..\src\other\sgm2508_EA;..\..\src\other\sgm41282_APD;..\..\src\other\sgm41295_EA_SOA;..\..\src\other\sgm41296_TEC;..\..\src\update;..\..\src\thermistor_rth;..\..\src\tec_control;..\..\src\ddm_process;..\..\src\ddm_process\ddm_1g_config;..\..\src\ddm_process\ddm_10g_config;..\..\src\ddm_process\ddm_50g_config;..\..\src\thd_dsp_download_release_V0_0
  library: MicroLIB
  memory RVCT4: ROM 0x8007800 size 0x15000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group mcu_Application
    ../../src/mcu/: com_usart_comm.c mcu_config_public.c mcu_global_vars_param.c mcu_system_comm.c timer_comm.c
    ../../src/mcu/i2c_opt_ie/: i2c_opt_ie.c
    ../../src/mcu/i2c_comm/: i2c_comm.c i2c_driver.c
    ../../src/mcu/GDE501_fireware/: gd32e501_it.c systick.c
    ../../src/mcu/dac_comm/: dac_comm.c dac_driver.c
    ../../src/mcu/adc_sample_comm/: adc_sample_comm.c adc_sample_driver.c adc_sample_interface.c
  group mcu_CMSIS
    ../../src/mcu/GDE501_fireware/Firmware/CMSIS/GD/GD32E501/Source/: system_gd32e501.c
  group mcu_Peripherals
    ../../src/mcu/GDE501_fireware/Firmware/GD32E501_standard_peripheral/Source/: gd32e501_adc.c gd32e501_cla.c gd32e501_cmp.c gd32e501_crc.c gd32e501_dac.c gd32e501_dbg.c gd32e501_dma.c gd32e501_exti.c gd32e501_fmc.c gd32e501_fwdgt.c gd32e501_gpio.c gd32e501_i2c.c gd32e501_mdio.c gd32e501_misc.c gd32e501_pmu.c gd32e501_rcu.c gd32e501_rtc.c gd32e501_spi.c gd32e501_syscfg.c gd32e501_timer.c gd32e501_usart.c gd32e501_wwdgt.c
  group mcu_Startup
    ../../src/mcu/GDE501_fireware/Firmware/CMSIS/GD/GD32E501/Source/ARM/: startup_gd32e501.s
  group mcu_Utilities
    ../../src/mcu/GDE501_fireware/Utilities/: gd32e501_eval.c
  group Doc
    ../: readme.txt
  group driver
    ../../src/driver/dsp_fsl/: dsp_fsl.c dsp_fsl_i2c_interface.c
    ../../src/driver/GN7153/: gn7153.c
    ../../src/driver/UX3326/: ux3326.c
  group other
    ../../src/other/sgm2508_EA/: sgm2508_ea.c
    ../../src/other/sgm41282_APD/: sgm41282c_apd.c
    ../../src/other/sgm41295_EA_SOA/: sgm41295_ea_soa.c
    ../../src/other/sgm41296_TEC/: sgm41296_tec.c
    ../../src/other/: trigger_interrupt_mode.c
  group tec_control
    ../../src/tec_control/: tec_comm.c tec_driver.c tec_i2c_interface.c
  group main
    ../../src/main/: main.c
  group update
    ../../src/update/: update_comm.c update_i2c_interface.c
  group include
    ../../src/include/: dev_reg_address.h prj_header_directory.h user_config.h
  group ddm_process
    ../../src/ddm_process/: ddm_i2c_interface.c ddm_sff_i2c_interface.c sff_8472.c
    ../../src/ddm_process/ddm_1g_config/: ddm_1g_config_interface.c
    ../../src/ddm_process/ddm_10g_config/: ddm_10g_config_interface.c
    ../../src/ddm_process/ddm_50g_config/: ddm_50g_config_interface.c
  group thermistor_rth
    ../../src/thermistor_rth/: thermistor_rth.c
  group thd_dsp_download
    ../../src/thd_dsp_download_release_V0_0/: do_cmd_struct.c dsp_hpll_init.c ip_op.c reg_op.c
software components: CMSIS:CORE 5.2.0
