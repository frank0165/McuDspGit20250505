# IAR project Project.ewp, settings and files
configuration GD32E501 (ARM, debug)
  General.OGChipSelectEditMenu: GD32E501xE GD GD32E501xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: GD32E501
  ICCARM.CCIncludePath2: ..; ..\..\Firmware\CMSIS\GD\GD32E501\Include; ..\..\Firmware\GD32E501_standard_peripheral\Include; ..\..\Utilities; ..\..\Firmware\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32e501_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32E501/Source/: system_gd32e501.c
  group Doc
    ../: readme.txt
  group GD32E501_EVAL
    ../../Utilities/: gd32e501_eval.c
  group GD32E501_Peripherals
    ../../Firmware/GD32E501_standard_peripheral/Source/: gd32e501_adc.c gd32e501_cla.c gd32e501_cmp.c gd32e501_crc.c gd32e501_dac.c gd32e501_dbg.c gd32e501_dma.c gd32e501_exti.c gd32e501_fmc.c gd32e501_fwdgt.c gd32e501_gpio.c gd32e501_i2c.c gd32e501_mdio.c gd32e501_misc.c gd32e501_pmu.c gd32e501_rcu.c gd32e501_rtc.c gd32e501_spi.c gd32e501_syscfg.c gd32e501_timer.c gd32e501_usart.c gd32e501_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32E501/Source/IAR/: startup_gd32e501.s
